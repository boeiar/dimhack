# IAR project Lpc214x_demo.ewp, settings and files
configuration Debug flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: FLASH
  ICCARM.CCIncludePath2: App\; Board\; modules\; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Lpc214x_demo.out
  ILINK.IlinkIcfFile: config\Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __RAM_DEBUG
  ILINK.IlinkIcfFile: config\RAM.icf
  group (top)
    app/: demo.c user_func.c
  group Common Source
    board/: cstartup.s
  group Modul Source
    modules/: drv_hd44780.c drv_hd44780_l.c LPC_Rtc.c LPC_SysControl.c LPC_Timer.c LPC_Uart.c LPC_Vic.c menu.c
